# Keil uVision project Blinky.uvprojx, settings and files
target TM4C129 RAM (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x20030000 size 0x10000
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
  group ::CMSIS
    C:/Keil/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/TM4C1294NCPDT/: startup_TM4C129.s system_tm4c129.c
target TM4C129 Flash (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 1.0.0
