# Keil uVision project Object.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Object +hex
  AfterMake: fromelf --bin --output .\OBJ\object.bin .\OBJ\object.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: .\Hardwares;.\Softwares;.\Main;.\Core;.\FreeRTOS\CMSIS\Include;.\FreeRTOS\CMSIS\Source\portable\ARM_CM4F;.\Tivaware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: Object.sct
  link misc: --entry Reset_Handler
  group Hardwares
    ./Hardwares/usart/: usart.c
    ./Hardwares/LED/: led.c
    ./Hardwares/HC_SR04/: hc_sr04.c
    ./Hardwares/PWM/: myPWM.c
    ./Hardwares/CAP/: myCap.c
    ./Hardwares/Timer/: myTimer.c
    ./Hardwares/MPU6050/: mpu6050.c
    ./Hardwares/IIC/: IIC_Hard.c
  group Softwares
    ./Softwares/Filter/: Filters.c
  group Main
    ./Main/: main.c
  group FreeRTOS
    ./FreeRTOS/CMSIS/Source/: clib_arm.c cmsis_os2.c event_groups.c freertos_evr.c list.c os_systick.c queue.c tasks.c timers.c
    ./FreeRTOS/CMSIS/Source/portable/ARM_CM4F/: port.c
    ./FreeRTOS/CMSIS/Source/portable/MemMang/: heap_4.c
  group Core
    ./Core/: system_TM4C123.c startup_TM4C123.s
  group TivaWares
    ./Tivaware/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    ./Tivaware/utils/: uartstdio.c ustdlib.c
